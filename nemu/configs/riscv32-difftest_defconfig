## nemu/configs/riscv32-difftest_defconfig
```kconfig
CONFIG_ISA_riscv=y
CONFIG_TARGET_NATIVE_ELF=y
CONFIG_TRACE=y
CONFIG_ITRACE=y
CONFIG_DIFFTEST=y
CONFIG_DIFFTEST_REF_SPIKE=y
```
